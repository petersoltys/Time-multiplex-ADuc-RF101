# Keil uVision project Radio.uvproj, settings and files
target Master (5060020::V5.06 (build 20)::ARMCC)
  device: ADuCRF101 Analog Devices
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x0000000-0x001FFFF) CLOCK(16000000) CPUTYPE("Cortex-M3")
  output: Radio +hex
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib;$K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Application
    ./src/: Slave.c Master.c
  group Common
    ../../Common/RealView/: startup_ADuCRF101.s Retarget.c
    ../../Common/: radioeng.c system_ADuCRF101.c
    ./src/: common.c settings.h
  group Libraries
    ../../DasLib/: AdcLib.c WutLib.c ClkLib.c DioLib.c GptLib.c IntLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c DmaLib.c
  group SD_SPI
    ./src/SD_SPI/: diskio.c diskio.h ff.c ff.h ffconf.h 00readme.txt history.txt
target Slave (ARM-ADS)
  device: ADuCRF101 Analog Devices
  cpu: as above
  output: Radio +hex
  c flags: Optim=1
  c include: ..\..\Common;..\..\DasLib; $K\ARM\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
