# IAR project Radio.ewp, settings and files
configuration Receive (ARM, debug)
  General.OGChipSelectEditMenu: ADUCRF101 AnalogDevices ADUCRF101
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\..\Common; ..\..\DasLib; $EW_DIR$\arm\CMSIS\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Radio.srec
  ILINK.IlinkOutputFile: Radio.out
  ILINK.IlinkIcfFile: ..\..\Common\IAR\ADUCRF101.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Transmit (ARM, debug)
  as the first configuration, except:
  group Application
    src/: receive.c transmit.c
  group Common
    ../../Common/: radioeng.c
    ../../Common/IAR/: Retarget.c startup_ADuCRF101.s
  group Libraries
    ../../DasLib/: AdcLib.c ClkLib.c DioLib.c GptLib.c IntLib.c PwrLib.c RstLib.c SpiLib.c UrtLib.c WdtLib.c WutLib.c
